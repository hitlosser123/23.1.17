# Keil uVision project TiPilot.uvprojx, settings and files
target TiPilot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TiPilot +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\FreeRTOS\include;..\FreeRTOS\portable;..\HardWare Driver;..\Tiva Ware\inc;..\Tiva Ware\driverlib;..\Tiva Ware\utils;..\Tiva Ware;..\User;..\FreeRTOS;..\Tasks;..\FramwWork;..\Tasks
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group User
    ./: main.c system_init.c includes.h tm4c123_it.c config&param.h
    ../: 更新日志.txt 接口保存.txt
  group TivaWare
    ../Tiva Ware/utils/: ustdlib.c uartstdio.c
    ../Tiva Ware/driverlib/rvmdk/: driverlib.lib
  group Tasks
    ../Tasks/: LedTask.c AutoflyTask.c DebugerTask.c RemoterTask.c SensorsTask.c StabilizerTask.c
  group FrameWork
    ../FramwWork/: adrc.c openmv.c AHRS.c anoV65.c debuger.c filter.c height.c IMU.c Kalman_Filter.c mag.c motors.c optical.c pid.c sbus.c SINS.c tf_mini_plus.c us_100.c x_linker.c x_wdp.c
  group HardWare
    ../HardWare Driver/: spi_master.c led.c drv_eeprom.c ak8975.c spi1.c delay.c x_exti.c x_gpio.c m0_pwm.c icm20602.c spl06.c uart1_dma.c uart2_dma.c uart3_dma.c uart4_dma.c uart5_dma.c uart6_dma.c uart7_dma.c m1_pwm.c drv_adc.c
  group Core
    ./: startup_rvmdk.S
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/: port.c
    ../FreeRTOS/MemMang/: heap_2.c
software components: CMSIS:CORE 5.0.1
